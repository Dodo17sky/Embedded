# Keil uVision project Dune.uvprojx, settings and files
target STM32F103C8 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Dune
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\include;.\SWC\LIGHTING;.\SWC\COM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: main.c String.c
  group include
    ./include/: GeneralTypes.h String.h Utils.h RingBuffer.h
  group System
    ./include/: System.h
    ./src/: System.c
  group Port
    ./include/: Port.h
    ./src/: Port.c
  group Timer
    ./src/: Timer.c
    ./include/: Timer.h
  group Task
    ./include/: Task.h
    ./src/: Task.c
  group Uart
    ./include/: Uart.h
    ./src/: Uart.c
  group SWC
    ./SWC/LIGHTING/: Lighting.c Lighting.h
    ./SWC/COM/: Com.c Com.h
  group SPI
    ./include/: Spi.h
    ./src/: Spi.c
  group WiFi
    ./include/: Wifi.h
    ./src/: Wifi.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
